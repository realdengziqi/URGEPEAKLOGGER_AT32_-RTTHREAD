# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ..\CORE;..\STM32L1xx_HAL_Driver\Inc;..\STM32L1xx_HAL_Driver\Src;..\USER;..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE\LED;..\HARDWARE\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ./: main.c stm32l1xx_it.c system_stm32l1xx.c
  group HANDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd_init.c lcd.c
  group FWLib
    ../STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc.c
  group CORE
    ../CORE/: startup_stm32l151xba.s
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
