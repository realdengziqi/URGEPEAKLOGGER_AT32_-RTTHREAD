# Keil uVision project surge_rtthread_base.uvprojx, settings and files
target surge_rtthread_base_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: surge_rtthread_base +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ARGT7,USE_STDPERIPH_DRIVER,__RTTHREAD__,__RT_KERNEL_SOURCE__,SURGE_UI_USE_RTTHREAD
  c include: ..\..\app\inc;..\..\bsp\at32f403\inc;..\..\drivers\screen\inc;..\..\drivers\sensor\inc;..\..\drivers\storage\inc;..\..\vendor\AT32F403A_407_Firmware_Library_V2.2.2\libraries\drivers\inc;..\..\vendor\AT32F403A_407_Firmware_Library_V2.2.2\libraries\cmsis\cm4\core_support;..\..\vendor\AT32F403A_407_Firmware_Library_V2.2.2\libraries\cmsis\cm4\device_support;..\..\vendor\rt-thread-v5.2.2\include;..\..\vendor\rt-thread-v5.2.2\include\klibc;..\..\vendor\rt-thread-v5.2.2\libcpu\arm\cortex-m4;..\..\vendor\rt-thread-v5.2.2\components\finsh;..\..\vendor\ugui;..\..\external_port\ugui_port;..\..\external_port\surge_ui_kit
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group app
    ../../app/src/: main.c app_main.c app_ui.c app_data_service.c app_bringup.c app_key_input.c app_rtc.c app_shell.c app_param_service.c app_record_service.c
    ../../app/inc/: app_ui.h app_data_service.h app_bringup.h app_key_input.h app_rtc.h app_shell.h app_param_service.h app_record_service.h
  group bsp
    ../../bsp/at32f403/src/: board.c at32f403a_407_clock.c at32f403_int.c
  group at32_driver
    ../../vendor/AT32F403A_407_Firmware_Library_V2.2.2/libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../../vendor/AT32F403A_407_Firmware_Library_V2.2.2/libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../vendor/AT32F403A_407_Firmware_Library_V2.2.2/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group readme
    ../../: 固件目录说明.md
  group rt-thread_kernel
    ../../vendor/rt-thread-v5.2.2/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../vendor/rt-thread-v5.2.2/src/klibc/: kstring.c kstdio.c rt_vsnprintf_tiny.c kerrno.c rt_vsscanf.c
  group rt-thread_libcpu
    ../../vendor/rt-thread-v5.2.2/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group drivers
    ../../drivers/screen/src/: screen_st7789.c
    ../../drivers/screen/inc/: screen_st7789.h
    ../../drivers/sensor/src/: sensor_hdc1080.c
    ../../drivers/sensor/inc/: sensor_hdc1080.h
    ../../drivers/storage/src/: storage_at24c128.c
    ../../drivers/storage/inc/: storage_at24c128.h
  group rt-thread_finsh
    ../../vendor/rt-thread-v5.2.2/components/finsh/: shell.c shell.h msh.c msh.h finsh.h
  group ui_middleware
    ../../vendor/ugui/: ugui.c ugui.h ugui_config.h system.h
    ../../external_port/ugui_port/: ugui_port.c ugui_port.h
    ../../external_port/surge_ui_kit/: surge_ui_widgets.c surge_ui_widgets.h surge_ui_style.h surge_ui_types.h surge_ui_font_zh_18.c surge_ui_font_zh_18.h surge_ui_font_zh_20.c surge_ui_font_zh_20.h surge_ui_font_zh_24.c surge_ui_font_zh_24.h
